/**
 * @file atlas_gfx.c
 * @brief High-Performance Embedded 2D Graphics and Font Engine for Atlas UI
 */
#include "atlas_gfx.h"
#include <string.h>
#include <stdlib.h>

/* Standard 5x7 ASCII font glyph table (ASCII 32 ' ' to 126 '~') */
static const uint8_t font5x7[95][5] = {
    {0x00, 0x00, 0x00, 0x00, 0x00}, /*   */
    {0x00, 0x00, 0x5F, 0x00, 0x00}, /* ! */
    {0x00, 0x07, 0x00, 0x07, 0x00}, /* " */
    {0x14, 0x7F, 0x14, 0x7F, 0x14}, /* # */
    {0x24, 0x2A, 0x7F, 0x2A, 0x12}, /* $ */
    {0x23, 0x13, 0x08, 0x64, 0x62}, /* % */
    {0x36, 0x49, 0x55, 0x22, 0x50}, /* & */
    {0x00, 0x05, 0x03, 0x00, 0x00}, /* ' */
    {0x00, 0x1C, 0x22, 0x41, 0x00}, /* ( */
    {0x00, 0x41, 0x22, 0x1C, 0x00}, /* ) */
    {0x08, 0x2A, 0x1C, 0x2A, 0x08}, /* * */
    {0x08, 0x08, 0x3E, 0x08, 0x08}, /* + */
    {0x00, 0x50, 0x30, 0x00, 0x00}, /* , */
    {0x08, 0x08, 0x08, 0x08, 0x08}, /* - */
    {0x00, 0x60, 0x60, 0x00, 0x00}, /* . */
    {0x20, 0x10, 0x08, 0x04, 0x02}, /* / */
    {0x3E, 0x51, 0x49, 0x45, 0x3E}, /* 0 */
    {0x00, 0x42, 0x7F, 0x40, 0x00}, /* 1 */
    {0x42, 0x61, 0x51, 0x49, 0x46}, /* 2 */
    {0x21, 0x41, 0x45, 0x4B, 0x31}, /* 3 */
    {0x18, 0x14, 0x12, 0x7F, 0x10}, /* 4 */
    {0x27, 0x45, 0x45, 0x45, 0x39}, /* 5 */
    {0x3C, 0x4A, 0x49, 0x49, 0x30}, /* 6 */
    {0x01, 0x71, 0x09, 0x05, 0x03}, /* 7 */
    {0x36, 0x49, 0x49, 0x49, 0x36}, /* 8 */
    {0x06, 0x49, 0x49, 0x29, 0x1E}, /* 9 */
    {0x00, 0x36, 0x36, 0x00, 0x00}, /* : */
    {0x00, 0x56, 0x36, 0x00, 0x00}, /* ; */
    {0x00, 0x08, 0x14, 0x22, 0x41}, /* < */
    {0x14, 0x14, 0x14, 0x14, 0x14}, /* = */
    {0x41, 0x22, 0x14, 0x08, 0x00}, /* > */
    {0x02, 0x01, 0x51, 0x09, 0x06}, /* ? */
    {0x32, 0x49, 0x79, 0x41, 0x3E}, /* @ */
    {0x7E, 0x11, 0x11, 0x11, 0x7E}, /* A */
    {0x7F, 0x49, 0x49, 0x49, 0x36}, /* B */
    {0x3E, 0x41, 0x41, 0x41, 0x22}, /* C */
    {0x7F, 0x41, 0x41, 0x22, 0x1C}, /* D */
    {0x7F, 0x49, 0x49, 0x49, 0x41}, /* E */
    {0x7F, 0x09, 0x09, 0x01, 0x01}, /* F */
    {0x3E, 0x41, 0x41, 0x51, 0x32}, /* G */
    {0x7F, 0x08, 0x08, 0x08, 0x7F}, /* H */
    {0x00, 0x41, 0x7F, 0x41, 0x00}, /* I */
    {0x20, 0x40, 0x41, 0x3F, 0x01}, /* J */
    {0x7F, 0x08, 0x14, 0x22, 0x41}, /* K */
    {0x7F, 0x40, 0x40, 0x40, 0x40}, /* L */
    {0x7F, 0x02, 0x04, 0x02, 0x7F}, /* M */
    {0x7F, 0x04, 0x08, 0x10, 0x7F}, /* N */
    {0x3E, 0x41, 0x41, 0x41, 0x3E}, /* O */
    {0x7F, 0x09, 0x09, 0x09, 0x06}, /* P */
    {0x3E, 0x41, 0x51, 0x21, 0x5E}, /* Q */
    {0x7F, 0x09, 0x19, 0x29, 0x46}, /* R */
    {0x46, 0x49, 0x49, 0x49, 0x31}, /* S */
    {0x01, 0x01, 0x7F, 0x01, 0x01}, /* T */
    {0x3F, 0x40, 0x40, 0x40, 0x3F}, /* U */
    {0x1F, 0x20, 0x40, 0x20, 0x1F}, /* V */
    {0x7F, 0x20, 0x18, 0x20, 0x7F}, /* W */
    {0x63, 0x14, 0x08, 0x14, 0x63}, /* X */
    {0x03, 0x04, 0x78, 0x04, 0x03}, /* Y */
    {0x61, 0x51, 0x49, 0x45, 0x43}, /* Z */
    {0x00, 0x00, 0x7F, 0x41, 0x41}, /* [ */
    {0x02, 0x04, 0x08, 0x10, 0x20}, /* \ */
    {0x41, 0x41, 0x7F, 0x00, 0x00}, /* ] */
    {0x04, 0x02, 0x01, 0x02, 0x04}, /* ^ */
    {0x40, 0x40, 0x40, 0x40, 0x40}, /* _ */
    {0x00, 0x01, 0x02, 0x04, 0x00}, /* ` */
    {0x20, 0x54, 0x54, 0x54, 0x78}, /* a */
    {0x7F, 0x48, 0x44, 0x44, 0x38}, /* b */
    {0x38, 0x44, 0x44, 0x44, 0x20}, /* c */
    {0x38, 0x44, 0x44, 0x48, 0x7F}, /* d */
    {0x38, 0x54, 0x54, 0x54, 0x18}, /* e */
    {0x08, 0x7E, 0x09, 0x01, 0x02}, /* f */
    {0x08, 0x14, 0x54, 0x54, 0x3C}, /* g */
    {0x7F, 0x08, 0x04, 0x04, 0x78}, /* h */
    {0x00, 0x44, 0x7D, 0x40, 0x00}, /* i */
    {0x20, 0x40, 0x44, 0x3D, 0x00}, /* j */
    {0x00, 0x7F, 0x10, 0x28, 0x44}, /* k */
    {0x00, 0x41, 0x7F, 0x40, 0x00}, /* l */
    {0x7C, 0x04, 0x18, 0x04, 0x78}, /* m */
    {0x7C, 0x08, 0x04, 0x04, 0x78}, /* n */
    {0x38, 0x44, 0x44, 0x44, 0x38}, /* o */
    {0x7C, 0x14, 0x14, 0x14, 0x08}, /* p */
    {0x08, 0x14, 0x14, 0x18, 0x7C}, /* q */
    {0x7C, 0x08, 0x04, 0x04, 0x08}, /* r */
    {0x48, 0x54, 0x54, 0x54, 0x20}, /* s */
    {0x04, 0x3F, 0x44, 0x40, 0x20}, /* t */
    {0x3C, 0x40, 0x40, 0x20, 0x7C}, /* u */
    {0x1C, 0x20, 0x40, 0x20, 0x1C}, /* v */
    {0x3C, 0x40, 0x30, 0x40, 0x3C}, /* w */
    {0x44, 0x28, 0x10, 0x28, 0x44}, /* x */
    {0x0C, 0x50, 0x50, 0x50, 0x3C}, /* y */
    {0x44, 0x64, 0x54, 0x4C, 0x44}, /* z */
    {0x00, 0x08, 0x36, 0x41, 0x00}, /* { */
    {0x00, 0x00, 0x7F, 0x00, 0x00}, /* | */
    {0x00, 0x41, 0x36, 0x08, 0x00}, /* } */
    {0x08, 0x08, 0x2A, 0x1C, 0x08}  /* ~ */
};

void atlas_gfx_clear(uint16_t *fb, uint16_t color)
{
    if (!fb) return;
    if (color == 0) {
        memset(fb, 0, ATLAS_LCD_BYTES);
    } else {
        for (int i = 0; i < ATLAS_LCD_PIXELS; i++) {
            fb[i] = color;
        }
    }
}

void atlas_gfx_fill_rect(uint16_t *fb, int x, int y, int w, int h, uint16_t color)
{
    if (!fb || x >= ATLAS_LCD_WIDTH || y >= ATLAS_LCD_HEIGHT || w <= 0 || h <= 0) return;
    int x1 = (x < 0) ? 0 : x;
    int y1 = (y < 0) ? 0 : y;
    int x2 = (x + w > ATLAS_LCD_WIDTH) ? ATLAS_LCD_WIDTH : (x + w);
    int y2 = (y + h > ATLAS_LCD_HEIGHT) ? ATLAS_LCD_HEIGHT : (y + h);

    for (int j = y1; j < y2; j++) {
        int row = j * ATLAS_LCD_WIDTH;
        for (int i = x1; i < x2; i++) {
            fb[row + i] = color;
        }
    }
}

void atlas_gfx_draw_rect(uint16_t *fb, int x, int y, int w, int h, uint16_t color)
{
    if (!fb || w <= 0 || h <= 0) return;
    atlas_gfx_fill_rect(fb, x, y, w, 1, color);
    atlas_gfx_fill_rect(fb, x, y + h - 1, w, 1, color);
    atlas_gfx_fill_rect(fb, x, y, 1, h, color);
    atlas_gfx_fill_rect(fb, x + w - 1, y, 1, h, color);
}

void atlas_gfx_draw_char(uint16_t *fb, int x, int y, char c, uint16_t fg, uint16_t bg, int scale)
{
    if (!fb || c < 32 || c > 126) c = ' ';
    const uint8_t *glyph = font5x7[c - 32];

    for (int col = 0; col < 5; col++) {
        uint8_t line = glyph[col];
        for (int row = 0; row < 7; row++) {
            uint16_t color = (line & (1 << row)) ? fg : bg;
            if (color != 0x0001) { /* 0x0001 treated as transparent */
                if (scale == 1) {
                    int px = x + col;
                    int py = y + row;
                    if (px >= 0 && px < ATLAS_LCD_WIDTH && py >= 0 && py < ATLAS_LCD_HEIGHT) {
                        fb[py * ATLAS_LCD_WIDTH + px] = color;
                    }
                } else {
                    atlas_gfx_fill_rect(fb, x + col * scale, y + row * scale, scale, scale, color);
                }
            }
        }
    }

    /* 1-pixel trailing column for character spacing */
    if (bg != 0x0001) {
        if (scale == 1) {
            int px = x + 5;
            for (int row = 0; row < 7; row++) {
                int py = y + row;
                if (px >= 0 && px < ATLAS_LCD_WIDTH && py >= 0 && py < ATLAS_LCD_HEIGHT) {
                    fb[py * ATLAS_LCD_WIDTH + px] = bg;
                }
            }
        } else {
            atlas_gfx_fill_rect(fb, x + 5 * scale, y, scale, 7 * scale, bg);
        }
    }
}

void atlas_gfx_draw_string(uint16_t *fb, int x, int y, const char *str, uint16_t fg, uint16_t bg, int scale)
{
    if (!fb || !str) return;
    int cur_x = x;
    while (*str) {
        atlas_gfx_draw_char(fb, cur_x, y, *str, fg, bg, scale);
        cur_x += 6 * scale;
        str++;
    }
}

void atlas_gfx_draw_string_centered(uint16_t *fb, int y, const char *str, uint16_t fg, uint16_t bg, int scale)
{
    if (!fb || !str) return;
    int len = (int)strlen(str);
    int total_w = len * 6 * scale;
    int x = (ATLAS_LCD_WIDTH - total_w) / 2;
    if (x < 0) x = 0;
    atlas_gfx_draw_string(fb, x, y, str, fg, bg, scale);
}

void atlas_gfx_draw_card(uint16_t *fb, int x, int y, int w, int h, const char *title, const char *tagline, bool selected)
{
    if (!fb) return;

    uint16_t bg_col     = selected ? COLOR_PANEL_SEL : COLOR_PANEL_BG;
    uint16_t border_col = selected ? COLOR_BORDER_SEL : COLOR_BORDER_NORM;

    /* Card background */
    atlas_gfx_fill_rect(fb, x, y, w, h, bg_col);

    /* Card border (2px thick when selected for strong visual cue) */
    atlas_gfx_draw_rect(fb, x, y, w, h, border_col);
    if (selected) {
        atlas_gfx_draw_rect(fb, x + 1, y + 1, w - 2, h - 2, border_col);
    }

    /* Accent top indicator bar on active card */
    if (selected) {
        atlas_gfx_fill_rect(fb, x + 4, y + 2, w - 8, 3, COLOR_CYAN);
    }

    /* Title */
    uint16_t title_col = selected ? COLOR_CYAN : COLOR_TEXT_MAIN;
    atlas_gfx_draw_string(fb, x + 10, y + 14, title, title_col, 0x0001, 1);

    /* Tagline */
    if (tagline && strlen(tagline) > 0) {
        atlas_gfx_draw_string(fb, x + 10, y + 34, tagline, COLOR_TEXT_MUTED, 0x0001, 1);
    }
}
